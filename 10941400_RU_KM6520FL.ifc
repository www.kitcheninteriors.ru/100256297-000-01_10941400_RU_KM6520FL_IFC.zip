Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0, FMHandOverView]
File name: Project Number
Time: 2021-06-16T11:06:15
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20190508_0315(x64) - Exporter 17.0.1169.0 - Default UI
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Wed Jun 16 11:06:15 2021 * Host: DEGTW9512 * Database: C:\Users\deschvi\AppData\Local\Temp\{5521C8C9-DA0F-4E72-89BA-574C76126233}\ifc * Database version: 5507 * Database creation date: Wed Jun 16 11:06:14 2021 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Wed Jun 16 11:06:14 2021 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Wed Jun 16 11:06:14 2021 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1

# IfcBuildingStorey, Level 1
LongName: Level 1; Elevation: 0 mm

# IfcBuildingElementProxy: 26652070_RU_10941400_KM6520FL, 10941400_RU_KM6520FL:26652070_RU_10941400_KM6520FL:204022
In: Level 1
Type - Classification: A-KM-7000 (Uniformat); Material: z_Miele_Design_CLST, z_Miele_Design_Glass Black, z_Miele_Connection_Electric, Default
Pset_BuildingElementProxyCommon - Reference: 26652070_RU_10941400_KM6520FL
Pset_ManufacturerTypeInformation - Manufacturer: Miele
